*
* Test 2N7000 characteristics
*
.include 2n7000.lib

XM 1 2 0 2N7000        ; D G S
VDS 1 0 10V
VGS 2 0 2.5V

.dc VDS  0.1  20  0.1
.probe alli

.control
set color0=white
* dc Vds  0.1  5  0.1
run
* plot v(1) i(VDS)
plot loglog -i(VDS)
.endc
